# IAR project Bird.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431CB ST STM32G431CB
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G431xx
  ICCARM.CCIncludePath2: $PROJ_DIR$; INS; driver; device; extend
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Bird.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp startup_stm32g431xx.s stm32g431xx.h stm32g431xx_flash.icf system_stm32g4xx.c system_stm32g4xx.h
  group device
    device/: camflow.cpp camflow.h crsf.cpp crsf.h flow.cpp flow.h gps.cpp gps.h joy.h led.cpp led.h sbus.cpp sbus.h tof.cpp tof.h
  group device/bars
    device/bars/: BMP280.cpp BMP280.h LPS22HH.cpp LPS22HH.h
  group device/eeproms
    device/eeproms/: AT24C256.cpp AT24C256.h
  group device/imus
    device/imus/: ICM20948.cpp ICM20948.h ICM40609.cpp ICM40609.h LSM6DS3TRC.cpp LSM6DS3TRC.h
  group device/interfaces
    device/interfaces/: IBar.cpp IBar.h IEEPROM.cpp IEEPROM.h IIMU.cpp IIMU.h IMag.cpp IMag.h
  group device/mags
    device/mags/: IST8310.cpp IST8310.h
  group driver
    driver/: adc.cpp adc.h dshot.cpp dshot.h dshot2.cpp dshot2.h flash.cpp flash.h gpio.cpp gpio.h i2c.cpp i2c.h pwm.cpp pwm.h spi.cpp spi.h tick.cpp tick.h tim.cpp tim.h uart.cpp uart.h
  group extend
    extend/: Analyser.cpp Analyser.h Autopilot.cpp Autopilot.h Biquad.cpp Biquad.h Filters.cpp Filters.h MathFunc.cpp MathFunc.h Med.cpp Med.h Messages.h PriorityQueue.cpp PriorityQueue.h Protocol.cpp Protocol.h Settings.cpp Settings.h SettingsTable.h
  group INS
    INS/: IRS.cpp IRS.h
  group INS/cont
    INS/cont/: Attitude.cpp Attitude.h Engine.cpp Engine.h Velocity.cpp Velocity.h
  group INS/device
    INS/device/: Barometer.cpp Barometer.h CameraFlow.cpp CameraFlow.h Compass.cpp Compass.h GPS.cpp GPS.h OpticalFlow.cpp OpticalFlow.h Range.cpp Range.h
  group INS/geom
    INS/geom/: Quaternion.cpp Quaternion.h Vector.cpp Vector.h
  group INS/util
    INS/util/: Record.cpp Record.h RegPDI.cpp RegPDI.h
