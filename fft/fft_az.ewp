# IAR project fft_az.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431CB ST STM32G431CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G431xx; ARM_MATH_CM4
  ICCARM.CCIncludePath2: $PROJ_DIR$; $TOOLKIT_DIR$\CMSIS\DSP\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    $EW_DIR$/arm/CMSIS/DSP/Include/: arm_math.h
    ./: dsp_manager.c dsp_manager.h imu.c imu.h main.c startup_stm32g431xx.s stm32g431xx.h stm32g4xx.h system_stm32g4xx.c system_stm32g4xx.h
    ../www/: motors.c motors.h
