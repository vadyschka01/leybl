# IAR project www.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431CB ST STM32G431CB
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G431xx
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: www.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: imu.c imu.h main.c mixer.c mixer.h motors.c motors.h pid.c pid.h sbus.c sbus.h startup_stm32g431xx.s stm32g431xx.h stm32g4xx.h system_stm32g4xx.c system_stm32g4xx.h
